# Keil uVision project SPI_REG.uvprojx, settings and files
target Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO_REG +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c misc: --asm --C99
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f103xb.h mystuff.c mystuff.h fxas21002c.h spi.c spi.h fxas21002c.c
software components: CMSIS:CORE 4.2.0, Device:Startup 1.0.0
